## uberos/buildroot/Config.in
```kconfig
menu "UBER/OS"
comment "UBER/OS Generation-0 uses a minimal rootfs overlay and no custom packages yet"
endmenu
```
